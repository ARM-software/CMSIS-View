# Keil uVision project Fault_S.uvprojx, settings and files
target B-U585I-IOT02A (6210000::V6.21::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Fault_S
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-unsafe-buffer-usage
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash_s.sct
  group Documentation
    ../: README.md
  group :STM32CubeMX_S:Common Sources
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure/Src/: main.c stm32u5xx_it.c secure_nsc.c
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure/Inc/: stm32u5xx_it.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure_nsclib/: secure_nsc.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
  group Interface
    ./: interface.c tz_context.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:Breakpoint 1.0.0, CMSIS-Compiler:STDIN:Breakpoint 1.0.0, CMSIS-Compiler:STDOUT:Breakpoint 1.0.0, CMSIS-View:Fault:Storage 1.0.1, CMSIS:CORE 6.0.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:Flash 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:GTZC 1.2.0, Device:STM32Cube HAL:ICACHE 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:STM32Cube LL:Common 1.2.0, Device:STM32Cube LL:GPIO 1.2.0, Device:STM32Cube LL:PWR 1.2.0, Device:STM32Cube LL:RCC 1.2.0, Device:STM32Cube LL:UTILS 1.2.0, Device:Startup 1.0.0
