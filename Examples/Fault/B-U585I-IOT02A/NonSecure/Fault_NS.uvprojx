# Keil uVision project Fault_NS.uvprojx, settings and files
target B-U585I-IOT02A (6210000::V6.21::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Fault_NS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RTE_Compiler_EventRecorder, RTE_Compiler_EventRecorder_DAP
  c misc: -Wno-unsafe-buffer-usage
  memory RVCT4: ROM 0x8100000 size 0x200000
  memory RVCT9: RAM 0x20040000 size 0x40000
  scatter file: .\RTE\Device\STM32U585AIIx\stm32u585xx_flash_ns.sct
  group Documentation
    ../: README.md
  group Source Files
    ./: Fault.c ARM_FaultTrigger.c ARM_FaultPrint.c retarget_stdio.c
  group :STM32CubeMX_NS:Common Sources
    ../Board/B-U585I-IOT02A/STM32CubeMX/NonSecure/Src/: main.c stm32u5xx_it.c
    ../Board/B-U585I-IOT02A/STM32CubeMX/NonSecure/Inc/: stm32u5xx_it.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/Secure_nsclib/: secure_nsc.h
    ../Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
  group CMSE Library
    ../Secure/: interface.h
    ../Secure/Objects/: Fault_S_CMSE_Lib.o
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 2.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS-View:Fault:Record 1.0.0, CMSIS-View:Fault:Storage 1.0.1, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:Flash 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:GTZC 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.0.0
